# Keil uVision project Project.uvproj, settings and files
target Project (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Project +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\USER\SetUp;..\USER;..\Libraries\CMSIS;..\Libraries\FWlib\inc;..\Drivers\delay;..\Drivers\Usart;..\Drivers\Rotating_Disk_Mechanism;..\Drivers\Ultrasonic;..\OLED;..\Drivers\sys;..\Drivers\DS1302
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ../USER/: stm32f10x_it.c main.c bsp_i2c_gpio.c max30102.c
    ../OLED/: oled.c
    ../Drivers/DS1302/: ds1302.c
  group Stdperiph_Driver
    ../Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group CMSIS
    ../Libraries/CMSIS/: core_cm3.c system_stm32f10x.c
  group Startup
    ../Libraries/CMSIS/startup/: startup_stm32f10x_md.s
  group Delay
    ../Drivers/delay/: delay.c
  group Usart
    ../Drivers/Usart/: USART.c
  group Ultrasonic
    ../Drivers/Ultrasonic/: ultrasonic.c
